# Keil uVision project debugger.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gd32f103cb_rblnano2_if
  BeforeMake: F:\file\gitprj\stm32f103_test\tools\pre_build_script.bat
  AfterMake: F:\file\gitprj\stm32f103_test\tools\post_build_script.bat $L@L $KARM
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: DAPLINK_VERSION=242, HID_ENDPOINT, MSC_ENDPOINT, CDC_ENDPOINT, DAPLINK_IF, DAPLINK_BUILD_KEY=0x9B939E8F, INTERFACE_GD32F103, CPU_GD32F103CBT6, DAPLINK_HIC_ID=0x97969905, BL_TARGET_FLASH, USE_STDPERIPH_DRIVER, GD32F10X_MD, USE_HSE_16MHZ
  c misc: --gnu --c99 --no_unaligned_access --no_unaligned_access
  c include: ..\..\startup;..\..\cmsis-core;..\src;..\..\GIGA32\inc;..\..\GIGA32\src;..\..\GIGA32\gd32\peripherals\inc;..\..\GIGA32\gd32\peripherals\src
  asm misc: --cpreproc --cpreproc_opts=-DDAPLINK_VERSION=242,-DHID_ENDPOINT,-DMSC_ENDPOINT,-DCDC_ENDPOINT,-DDAPLINK_IF,-DDAPLINK_BUILD_KEY=0x9B939E8F,-DINTERFACE_GD32F103,-DCPU_GD32F103CBT6,-DDAPLINK_HIC_ID=0x97969905,-DBL_TARGET_FLASH,-DUSE_STDPERIPH_DRIVER,-DGD32F10X_MD,-DUSE_HSE_16MHZ --no_unaligned_access
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\..\GIGA32\inc\daplink.sct
  link misc: --predefine="-DDAPLINK_IF" --predefine="-I..\..\GIGA32\gd32"
  group startup
    ../../startup/: startup_gd32f10x_md.s
  group lib
    ../../GIGA32/gd32/peripherals/src/: gd32f10x_exti.c gd32f10X_fmc.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_rcc.c gd32f10x_usart.c
    ../../GIGA32/gd32/: read_uid.c system_gd32f10x.c SW_DP.c
  group app
    ../src/: loop.c uart.c main.c
    ../../GIGA32/src/: DAP.c
